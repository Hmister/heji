# Keil uVision project WZ01_CZ_A_V1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LED点阵 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src\Dirvers;.\src\FontLib;.\src\Share
  group Source Group 1
    ./src/: main.c
    ./src/Dirvers/: Delay.c OLED.c Uart1.c Uart3.c Max7219.c
    ./src/Share/: FG_Tool.c
    ./src/FontLib/: ASCII_CODE_8X16_5X8_VERTICAL.c CHINIESE_AND_GRAPHIC.c
